# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\user;.\system
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_md.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c
  group user
    ./user/: main.c CRC.C ymodem.c U2_CAN_agreement.c
  group System
    ./system/: AT24C0X.C IntToString.c CAN.C JumpAPP.C USART.C system_Init.c
software components: CMSIS:CORE 5.1.2
